options:
  parameters:
    author: Mark Grennan
    description: Tunable narrowband FM voice receiver for the 2m/70cm ham bands. Key up the handheld and listen through the laptop speakers.
    generate_options: qt_gui
    id: nbfm_voice_receiver
    output_language: python
    title: 'SDR Demo 2: Tunable NBFM Voice Receiver'
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: HackRF capture rate feeding the channel filter
    value: 2e6
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    comment: Must be an integer multiple of audio_rate; feeds analog.nbfm_rx
    value: audio_rate * 8
  states: {}
- name: channel_freq
  id: variable_qtgui_entry
  parameters:
    comment: 146.520e6 = 2m calling, 446.000e6 = 70cm calling. Type any repeater output freq + Enter.
    gui_hint: 0,0,1,3
    label: Channel Freq (Hz)
    type: real
    value: 146.520e6
  states: {}
- name: lna_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,3
    label: LNA Gain (dB)
    start: '0'
    step: '8'
    stop: '40'
    value: '32'
  states: {}
- name: vga_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,3,1,3
    label: VGA Gain (dB)
    start: '0'
    step: '2'
    stop: '62'
    value: '20'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,3
    label: Volume
    start: '0'
    step: '0.05'
    stop: '2'
    value: '1.0'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: channel_freq
    gain: lna_gain
    samp_rate: samp_rate
    type: fc32
    vga: vga_gain
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: Isolate one 16 kHz-wide NBFM channel out of the wideband capture
    cutoff_freq: '7500'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '3000'
    win: window.WIN_HAMMING
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    comment: Downsample from samp_rate to quad_rate for the FM demodulator
    nfilts: '32'
    rrate: quad_rate / samp_rate
    type: ccf
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: audio_rate
    max_dev: 5e3
    quad_rate: quad_rate
    tau: '75e-6'
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: volume
    type: float
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: channel_freq
    fftsize: '2048'
    gui_hint: 2,0,2,6
    int_max: '-10'
    int_min: '-100'
    name: '"Wideband capture around channel"'
    type: complex
  states: {}

connections:
- [soapy_hackrf_source_0, '0', low_pass_filter_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_0, '0', pfb_arb_resampler_xxx_0, '0']
- [pfb_arb_resampler_xxx_0, '0', analog_nbfm_rx_0, '0']
- [analog_nbfm_rx_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_multiply_const_xx_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
