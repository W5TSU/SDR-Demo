options:
  parameters:
    author: Mark Grennan
    comment: 'RECEIVE ONLY, no license needed. Captures the entire 20m amateur band (14.000-14.350 MHz) in one instantaneous bandwidth and envelope-detects the whole thing as one AM audio stream -- not tuned to any single station. The result is a live cacophony: every CW/SSB/AM/data signal active on the band at once, mixed together the way a broadband envelope detector would hear it, rather than one clean demodulated conversation. SSB signals in particular will sound garbled/warbly through plain AM envelope detection since they carry no carrier -- that is expected, not a bug.'
    description: Wideband AM-envelope receiver for the entire 20m band -- "what does the whole band sound like at once" rather than a single-station AM receiver.
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: hf_20m_band_wideband_am
    output_language: python
    title: 'Bonus: Whole-Band 20m AM Envelope Receiver'
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: Center of the 20m band (14.000-14.350 MHz)
    value: 14.175e6
  states: {}
- name: lna_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: LNA Gain (dB)
    start: '0'
    step: '8'
    stop: '40'
    value: '32'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: 1 Msps is the lowest rate this HackRF/SoapySDR combo accepts (integer MHz steps only -- see flowgraphs/06's comment for the same constraint) and covers 13.675-14.675 MHz, comfortably containing the full 350 kHz-wide 20m band (14.000-14.350 MHz) with wide margin on both edges.
    value: 1e6
  states: {}
- name: vga_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,2
    label: VGA Gain (dB)
    start: '0'
    step: '2'
    stop: '62'
    value: '32'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    comment: Envelope-detected + DC-blocked audio runs much quieter than a normal demodulator's output, hence the wider 0-10 range and higher default than the other RX flowgraphs in this kit.
    gui_hint: 0,4,1,2
    label: Volume
    start: '0'
    step: '0.1'
    stop: '10'
    value: '3.0'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    comment: 'The whole trick: envelope-detect (AM demod) the raw wideband IQ directly, with no channel filter first -- every signal present across the full capture contributes to the resulting envelope at once.'
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: volume
    type: float
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    comment: Removes the DC bias every AM envelope carries (proportional to total in-band power) so only the audible variation remains.
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    comment: Downsample the real envelope signal from samp_rate to audio_rate
    nfilts: '32'
    rrate: audio_rate / samp_rate
    type: fff
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: center_freq
    fftsize: '4096'
    grid: 'True'
    gui_hint: 3,0,1,4
    name: '"Spectrum"'
    type: complex
    ymax: '0'
    ymin: '-100'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: Watch activity across the whole band while listening to the mix
    fc: center_freq
    fftsize: '4096'
    gui_hint: 1,0,2,4
    int_max: '-10'
    int_min: '-100'
    name: '"20m band (14.000-14.350 MHz)"'
    type: complex
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: 'True'
    center_freq: center_freq
    comment: RF amp defaults on -- HF signals through a simple wire antenna are typically much weaker than the VHF/UHF signals elsewhere in this kit.
    gain: lna_gain
    samp_rate: samp_rate
    type: fc32
    vga: vga_gain
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', dc_blocker_xx_0, '0']
- [blocks_multiply_const_xx_0, '0', audio_sink_0, '0']
- [dc_blocker_xx_0, '0', pfb_arb_resampler_xxx_0, '0']
- [pfb_arb_resampler_xxx_0, '0', blocks_multiply_const_xx_0, '0']
- [soapy_hackrf_source_0, '0', blocks_complex_to_mag_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
