options:
  parameters:
    author: Mark Grennan
    description: Live spectrum + waterfall on any HackRF-tunable frequency. Retune live between 146.520 MHz (2m calling freq) and 446.000 MHz (70cm calling freq) to show both bands with one flowgraph.
    generate_options: qt_gui
    id: spectrum_waterfall_tunable
    output_language: python
    title: 'SDR Demo 1: Live Spectrum & Waterfall (2m / 70cm)'
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: 10 MHz gives good context around whichever ham band you tune to
    value: 10e6
  states: {}
- name: center_freq
  id: variable_qtgui_entry
  parameters:
    comment: Type a new frequency + Enter to retune live. 146.520e6 = 2m calling, 446.000e6 = 70cm calling
    gui_hint: 0,0,1,2
    label: Center Freq (Hz)
    type: real
    value: 146.520e6
  states: {}
- name: lna_gain
  id: variable_qtgui_range
  parameters:
    comment: HackRF IF/LNA gain, 0-40 dB in 8 dB steps
    gui_hint: 0,2,1,2
    label: LNA Gain (dB)
    start: '0'
    step: '8'
    stop: '40'
    value: '24'
  states: {}
- name: vga_gain
  id: variable_qtgui_range
  parameters:
    comment: HackRF baseband VGA gain, 0-62 dB in 2 dB steps
    gui_hint: 0,4,1,2
    label: VGA Gain (dB)
    start: '0'
    step: '2'
    stop: '62'
    value: '20'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: center_freq
    gain: lna_gain
    samp_rate: samp_rate
    type: fc32
    vga: vga_gain
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: center_freq
    fftsize: '4096'
    grid: 'True'
    gui_hint: 1,0,1,6
    name: '"Spectrum"'
    type: complex
    ymax: '0'
    ymin: '-100'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '4096'
    gui_hint: 2,0,2,6
    int_max: '-10'
    int_min: '-100'
    name: '"Waterfall"'
    type: complex
  states: {}

connections:
- [soapy_hackrf_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
