options:
  parameters:
    author: Mark Grennan
    comment: 'BONUS / ICEBREAKER DEMO. Not ham-band, but a great opener: everyone instantly recognizes music, which proves the HackRF + GNU Radio chain works before moving on to the ham-band demos. No license needed to receive.'
    description: Wideband FM broadcast receiver (88-108 MHz), adapted from the stock GNU Radio SoapySDR example.
    generate_options: qt_gui
    id: bonus_fm_broadcast_receiver
    output_language: python
    title: 'SDR Demo 0 (Bonus): FM Broadcast Radio Receiver'
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: This HackRF only accepts integer-MHz sample rates (1-20 Msps in 1 MHz steps) -- 2.4e6 (the classic RTL-SDR FM-broadcast rate) is rejected at runtime with "Unsupported sample rate". 2 Msps is plenty of margin for one 200 kHz-wide WBFM broadcast channel.
    value: 2e6
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: station_freq
  id: variable_qtgui_entry
  parameters:
    comment: Pick any strong local FM broadcast station, e.g. 101.1e6
    gui_hint: 0,0,1,3
    label: Station Freq (Hz)
    type: real
    value: 101.1e6
  states: {}
- name: lna_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,3
    label: LNA Gain (dB)
    start: '0'
    step: '8'
    stop: '40'
    value: '24'
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,3
    label: Volume
    start: '0'
    step: '0.05'
    stop: '2'
    value: '0.6'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: station_freq
    gain: lna_gain
    samp_rate: samp_rate
    type: fc32
    vga: '20'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: Isolate one 200 kHz-wide WBFM broadcast channel
    cutoff_freq: 100e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 20e3
    win: window.WIN_HAMMING
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: (audio_rate * 2) / samp_rate
    type: ccf
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '2'
    comment: Quadrature rate is audio_rate * 2
    quad_rate: audio_rate * 2
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: vol
    type: float
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: station_freq
    fftsize: '2048'
    gui_hint: 2,0,2,6
    int_max: '-10'
    int_min: '-100'
    type: complex
  states: {}

connections:
- [soapy_hackrf_source_0, '0', low_pass_filter_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_0, '0', pfb_arb_resampler_xxx_0, '0']
- [pfb_arb_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_multiply_const_xx_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
