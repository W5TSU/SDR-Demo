options:
  parameters:
    author: Mark Grennan
    comment: 'THE MAIN DEMO, part 2 of 2. Reads the IQ file captured by 03_record_2m_band_to_file.grc and transmits it back out over the air on the 2m band via the HackRF sink. LEGAL NOTE: only run this while a licensed control operator is present and identifying per Part 97 -- see README.md.'
    description: Plays back a previously recorded wideband 2m IQ file through the HackRF transmitter, reproducing the whole captured band on the air.
    generate_options: qt_gui
    id: playback_2m_band_from_file
    output_language: python
    title: 'SDR Demo 3b: Play the 2m Band Recording Back Over the Air'
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: Must match the samp_rate used in 03_record_2m_band_to_file.grc (6e6)
    value: 6e6
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: Must match the center_freq used in 03_record_2m_band_to_file.grc (146.0e6)
    value: 146.0e6
  states: {}
- name: replay_file
  id: variable
  parameters:
    comment: Edit this path to point at the file written by the recorder flowgraph
    value: '''/home/w5tsu/Development/SDR-Demo/recordings/2m_band_capture.iqmeta'''
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    comment: Start LOW (10-15 dB) and bring up only as far as needed. This is a live transmitter.
    gui_hint: 0,0,1,3
    label: TX VGA Gain (dB)
    start: '0'
    step: '2'
    stop: '47'
    value: '10'
  states: {}
- name: blocks_file_meta_source_0
  id: blocks_file_meta_source
  parameters:
    comment: Detached header must stay False -- it must match how 03_record_2m_band_to_file.grc wrote the file. repeat=True loops the recording continuously; set to 'False' for a single play-through.
    detached: 'False'
    file: replay_file
    repeat: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: Shows exactly what is about to be sent to the HackRF sink
    fc: center_freq
    fftsize: '4096'
    gui_hint: 1,0,2,4
    int_max: '-10'
    int_min: '-100'
    name: '"Signal being transmitted"'
    type: complex
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: center_freq
    samp_rate: samp_rate
    type: fc32
    vga: tx_gain
  states: {}

connections:
- [blocks_file_meta_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_file_meta_source_0, '0', soapy_hackrf_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
