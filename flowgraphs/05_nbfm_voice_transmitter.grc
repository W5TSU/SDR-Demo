options:
  parameters:
    author: Mark Grennan
    comment: 'LEGAL NOTE: this transmits live RF on the ham bands. Only run this while a licensed control operator is present and identifying per Part 97 -- see README.md. Talk into the laptop mic; listen on the handheld tuned to the same frequency.'
    description: Narrowband FM voice transmitter -- laptop mic to HackRF, for a live two-way demo with the handheld radio.
    generate_options: qt_gui
    id: nbfm_voice_transmitter
    output_language: python
    title: 'SDR Demo 4: NBFM Voice Transmitter (Mic to Air)'
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    comment: Must be an integer multiple of audio_rate. analog.nbfm_tx designs its interpolation filter with pm_remez (Parks-McClellan), which is numerically fragile at high interpolation factors -- audio_rate*8 (interp=8) throws "insufficient extremals -- cannot continue" on construction. interp=4 tested clean; 2-6 all work, 8 fails.
    value: audio_rate * 4
  states: {}
- name: xmit_rate
  id: variable
  parameters:
    comment: HackRF TX sample rate -- 2 Msps is comfortably within HackRF spec
    value: 2e6
  states: {}
- name: tx_freq
  id: variable_qtgui_entry
  parameters:
    comment: 146.520e6 = 2m simplex calling. Set the handheld to the same frequency, narrow/FM, no tone.
    gui_hint: 0,0,1,3
    label: TX Freq (Hz)
    type: real
    value: 146.520e6
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    comment: Start LOW and bring up only as far as needed -- this is a live transmitter
    gui_hint: 0,3,1,3
    label: TX VGA Gain (dB)
    start: '0'
    step: '2'
    stop: '47'
    value: '10'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    comment: Laptop microphone
    samp_rate: audio_rate
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: quad_rate
    tau: '75e-6'
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    comment: Upsample from quad_rate to xmit_rate for the HackRF sink
    nfilts: '32'
    rrate: xmit_rate / quad_rate
    type: ccf
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: xmit_rate
    fc: tx_freq
    fftsize: '2048'
    grid: 'True'
    gui_hint: 1,0,2,6
    name: '"Modulated TX signal"'
    type: complex
    ymax: '0'
    ymin: '-100'
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: tx_freq
    samp_rate: xmit_rate
    type: fc32
    vga: tx_gain
  states: {}

connections:
- [audio_source_0, '0', analog_nbfm_tx_0, '0']
- [analog_nbfm_tx_0, '0', pfb_arb_resampler_xxx_0, '0']
- [pfb_arb_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [pfb_arb_resampler_xxx_0, '0', soapy_hackrf_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
