options:
  parameters:
    author: Mark Grennan
    comment: THE MAIN DEMO, part 1 of 2. Captures the entire 2 meter ham band (144.000-148.000 MHz) as raw IQ to a file. Run 04_playback_2m_band_from_file.grc afterward to transmit the recording back out. Stop the flowgraph (red square) to end the recording -- the file is only flushed/closed on stop.
    description: Wideband IQ capture of the full 2m band to a GNU Radio file-meta file (self-describing -- sample rate and center frequency are stored in the header).
    generate_options: qt_gui
    id: record_2m_band_to_file
    output_language: python
    title: 'SDR Demo 3: Record the Entire 2m Band to a File'
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: 6 MHz centered on 146.0 MHz covers 143.0-149.0 MHz -- the full 144-148 MHz 2m band plus margin for filter roll-off. Keep this fixed so playback matches exactly.
    value: 6e6
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: Center of the 2m band (144.000-148.000 MHz). Keep this fixed so playback matches exactly.
    value: 146.0e6
  states: {}
- name: capture_file
  id: variable
  parameters:
    comment: Edit this path to change where the recording is written. ~2.9 GB/minute at 6 Msps complex float32 -- plan recording length accordingly.
    value: '''/home/w5tsu/Development/SDR-Demo/recordings/2m_band_capture.iqmeta'''
  states: {}
- name: lna_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: LNA Gain (dB)
    start: '0'
    step: '8'
    stop: '40'
    value: '32'
  states: {}
- name: vga_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,2
    label: VGA Gain (dB)
    start: '0'
    step: '2'
    stop: '62'
    value: '24'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: center_freq
    gain: lna_gain
    samp_rate: samp_rate
    type: fc32
    vga: vga_gain
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: Watch for HT activity across the whole band while recording
    fc: center_freq
    fftsize: '4096'
    gui_hint: 1,0,2,4
    int_max: '-10'
    int_min: '-100'
    name: '"2m band (144-148 MHz)"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: center_freq
    fftsize: '4096'
    grid: 'True'
    gui_hint: 3,0,1,4
    name: '"Spectrum"'
    type: complex
    ymax: '0'
    ymin: '-100'
  states: {}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    comment: Recording starts the instant this flowgraph runs. Stop the flowgraph to flush and close the file.
    detached: 'False'
    extra_dict: pmt.make_dict()
    file: capture_file
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: complex
  states: {}

connections:
- [soapy_hackrf_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', blocks_file_meta_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
