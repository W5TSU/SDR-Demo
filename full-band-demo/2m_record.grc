options:
  parameters:
    author: W5TSU
    description: Record the 2m band (144.0-148.0 MHz) with margin using HackRF
    generate_options: qt_gui
    id: two_m_record
    output_language: python
    title: 2M Band Recorder
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    comment: 5 Msps centered here covers 143.5-148.5 MHz -- symmetric 0.5 MHz margin on both sides of the real 2m band (144.0-148.0), clear of the Nyquist-edge filter rolloff that a 146.5 MHz center (0 MHz margin at 144.0, 1 MHz wasted above 148.0) used to sit right on top of.
    gui_hint: 0,0,1,1
    label: Center Frequency (Hz)
    start: '144000000'
    step: '1000'
    stop: '149000000'
    value: '146000000'
  states: {}
- name: lna_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: LNA Gain (dB)
    rangeType: int
    start: '0'
    step: '8'
    stop: '40'
    value: '32'
  states: {}
- name: out_file
  id: variable
  parameters:
    value: '"/tmp/2m_capture.iq"'
  states: {}
- name: record_time
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: Record Time (s)
    rangeType: int
    start: '1'
    step: '1'
    stop: '600'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '5000000'
  states: {}
- name: vga_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: VGA Gain (dB)
    rangeType: int
    start: '0'
    step: '2'
    stop: '62'
    value: '40'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: out_file
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(samp_rate * record_time)
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=0"'
    bb_gain0: vga_gain
    bw0: samp_rate
    freq0: center_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: lna_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,0,1,3
    name: '"2M Band Spectrum"'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,0,1,3
    name: '"2M Band Waterfall"'
    showports: 'True'
    type: complex
  states: {}

connections:
- [osmosdr_source_0, '0', blocks_head_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
