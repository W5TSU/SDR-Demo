options:
  parameters:
    description: Play back recorded 2M IQ file via HackRF
    generate_options: qt_gui
    id: two_m_playback
    output_language: python
    title: 2M Band Playback
  states: {}

blocks:
- name: center_freq
  id: parameter
  parameters:
    comment: Must match the recording's center_freq -- 146.0 MHz keeps the 5 Msps span (143.5-148.5 MHz) symmetric around the real 2m band (144.0-148.0 MHz) instead of sitting right on the Nyquist edge.
    label: Center Frequency (Hz)
    type: eng_float
    value: '146000000'
  states: {}
- name: in_file
  id: parameter
  parameters:
    label: IQ input file
    type: str
    value: '"/tmp/2m_capture.iq"'
  states: {}
- name: num_samples
  id: variable
  parameters:
    value: (int(__import__('os').path.getsize(in_file) // 8) if __import__('os').path.exists(in_file) else 1)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '5000000'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: TX VGA Gain (dB)
    rangeType: int
    start: '0'
    step: '1'
    stop: '47'
    value: '20'
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: num_samples
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: in_file
    repeat: 'False'
    type: complex
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '20'
    bw0: samp_rate
    freq0: center_freq
    gain0: '0'
    if_gain0: tx_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,0,1,2
    name: '"2M Playback Spectrum"'
    showports: 'True'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_head_0, '0']
- [blocks_head_0, '0', osmosdr_sink_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
